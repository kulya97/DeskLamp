# Keil uVision project MotorControl.uvproj, settings and files
target Project (MCS-51)
  device: STC8F2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: MotorControl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User\Inc;.\Driver\Inc;.\User;D:\Keil_v5\C51\INC\SiLABS\shared\si8051Base
  group User
    ./User/: main.c commond.h
  group Dirver
    ./Driver/Src/: ws2812.c EEPROM.c
    ./Driver/Inc/: ws2812.h STC8FXXX.h EEPROM.h
